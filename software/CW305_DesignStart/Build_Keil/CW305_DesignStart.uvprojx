# Keil uVision project CW305_DesignStart.uvprojx, settings and files
target CW305_DesignStart (6100001::V6.10.1::.\ARMCLANG)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: CW305_DesignStart +hex
  AfterMake: make_hex_a7.bat
  c flags: Optim=2 oTime=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: CORTEX_M3 ARTY_CM3, TINYAES128C, SS_VER=1, DuECC_SUPPORTS_secp160r1=0, DuECC_SUPPORTS_secp192r1=0, DuECC_SUPPORTS_secp224r1=0, DuECC_SUPPORTS_secp256k1=0 , DuECC_ENABLE_VLI_API, DuECC_PLATFORM=uECC_arm, DuECC_OPTIMIZATION_LEVEL=4
  c include: ..\cmsis\CMSIS\Include;..\cmsis\Device\Include;..\cmsis\Device\Include\ARTY_CM3;..\main;..\gpio;..\uart;..\spi;..\sdk_workspace\standalone_bsp_0\Cortex_M3_0\include;..\simpleserial;..\crypto;..\crypto\tiny-AES128-C;..\crypto\micro-ecc
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry=Reset_Handler
  group CMSIS
    ../cmsis/Device/Source/ARTY_CM3/: system_ARTY_CM3.c
    ../cmsis/Device/Source/ARTY_CM3/ARM/: startup_ARTY_CM3.s
  group Standalone_v6_7
    ../sdk_workspace/standalone_bsp_0/Cortex_M3_0/libsrc/standalone_v6_7/src/: outbyte.c print.c xil_assert.c inbyte.c
  group Main
    ../main/: cw_main.c
  group GPIO
    ../gpio/: cw_gpio.c
  group UART
    ../uart/: uart.c
  group Xilinx_GPIO
    ../sdk_workspace/standalone_bsp_0/Cortex_M3_0/libsrc/gpio_v4_4/src/: xgpio.c xgpio_extra.c xgpio_g.c xgpio_intr.c xgpio_selftest.c xgpio_sinit.c
  group Xilinx_UART
    ../sdk_workspace/standalone_bsp_0/Cortex_M3_0/libsrc/uartlite_v3_2/src/: xuartlite.c xuartlite_g.c xuartlite_intr.c xuartlite_l.c xuartlite_selftest.c xuartlite_sinit.c xuartlite_stats.c
  group simpleserial
    ../simpleserial/: simpleserial.c
  group crypto
    ../crypto/: aes-independant.c
    ../crypto/tiny-AES128-C/: aes.c
target CW305_DesignStart_sim (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: CW305_DesignStart +hex
  AfterMake: make_hex_a7.bat
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: CORTEX_M1 ARTY_CM1 SIM_BUILD
  c include: ..\cmsis\CMSIS\Include;..\cmsis\Device\Include;..\cmsis\Device\Include\ARTY_CM1;..\sdk_workspace\standalone_bsp_0\Cortex_M3_0\include;..\main;..\platform;..\gpio;..\uart;..\spi
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --entry=Reset_Handler
target CW305_DesignStart_v2c (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.4.0
  cpu: as above
  output: CW305_DesignStart +hex
  AfterMake: make_hex_a7.bat
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: CORTEX_M3 ARTY_CM3
  c include: ..\cmsis\CMSIS\Include;..\cmsis\Device\Include;..\cmsis\Device\Include\ARTY_CM3;..\main;..\gpio;..\uart;..\spi;..\sdk_workspace\standalone_bsp_0\Cortex_M3_0\include
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry=Reset_Handler
software components: CMSIS:CORE 5.1.2
